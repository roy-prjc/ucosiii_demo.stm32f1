# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Stm32f10xlib_v_3_5\inc;..\Core;..\User;..\System\delay;..\System\sys;..\System\usart;..\App\led;..\UcosIII_v3_0_3\uC-CPU;..\UcosIII_v3_0_3\uC-LIB;..\UcosIII_v3_0_3\uCOS-III;..\UcosIII_v3_0_3\UCOS_BSP;..\UcosIII_v3_0_3\uCOS_CONFIG;..\UcosIII_v3_0_3\uCOS-III\Source;..\UcosIII_v3_0_3\uC-CPU\ARM-Cortex-M3\RealView;..\UcosIII_v3_0_3\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UcosIII_v3_0_3\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Log
    ../Log/: Log.txt
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group Lib
    ../Stm32f10xlib_v_3_5/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group led
    ../App/led/: user_led.c
  group UCOSIII_BSP
    ../UcosIII_v3_0_3/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UcosIII_v3_0_3/uC-CPU/: cpu_core.c
    ../UcosIII_v3_0_3/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UcosIII_v3_0_3/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UcosIII_v3_0_3/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UcosIII_v3_0_3/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UcosIII_v3_0_3/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../UcosIII_v3_0_3/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group README
    ../: README.TXT
